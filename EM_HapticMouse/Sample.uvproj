# Keil uVision project Sample.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC11U37/501 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Sample +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3
  c include: .\inc;.\inc\Led_Effect_H
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0xc000
  memory RVCT9: RAM 0x10000100 size 0x1e60
  memory RVCT10: RAM 0x20004000 size 0x800
  group Main
    ./src/: Main.c
  group Source
    ./src/: GPIO.c I2C.c OSC.c SPI.c Timer.c UART.c ADC.c gtech_flash.c operation_flash.c pc_communicate.c macro.c keydef.c suspend.c wnDrv_Pmu.c eeprom.c WWDT.c IAP_CMD.c my_tick.c my_i2c.c my_charger.c my_queue.c my_debug.c my_electromagnet.c my_misc.c my_protocol.c my_protocol_mouse.c TI_DRV8833.c PAW3950.c my_adc.c my_pwm.c my_waveform.c
  group USB
    ./src/: hiduser.c usbdesc.c usbhw.c usbuser.c usb.c usbcore.c
  group Startup
    ./src/: core_cm0.c startup_LPC11Uxx.s
  group App
    ./src/: device.c
    ./app/: scroll.c custom.c optical_3325.c
  group Led_Effect_Group
    ./Led_Effect_Gruop_Code/: test.c Production_line_test.c ram_malloc.c breath.c color_cycle.c led2.c reaction.c static.c
    ./app/: button.c
